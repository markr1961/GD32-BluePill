# IAR project GD32F303_test.ewp, settings and files
configuration GD32F303-release (ARM)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_CL; __ICCARM__
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: Inc; ..\GD32F30x_Firmware_Library_V2.1.5\Firmware\GD32F30x_standard_peripheral\Include; ..\GD32F30x_Firmware_Library_V2.1.5\Firmware\CMSIS\GD\GD32F30x\Include; ..\GD32F30x_Firmware_Library_V2.1.5\Firmware\CMSIS
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BPATH$.bin
  ILINK.IlinkOutputFile: GD32F303Test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F303-debug (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: GD32F30X_CL; USE_STDPERIPH_DRIVER; DEBUG; __ICCARM__
  ICCARM.CCIncludePath2: Inc; ..\GD32f30x_Firmware_Library_V2.1.5\Firmware\CMSIS; ..\GD32f30x_Firmware_Library_V2.1.5\Firmware\CMSIS\GD\GD32F30x\Include; ..\GD32f30x_Firmware_Library_V2.1.5\Firmware\GD32F30x_standard_peripheral\Include
  ICCARM.CCOptLevel: 1
  group (top)
    ./: GD32F303_test.c
  group Driver
    Drv/: Clocks.c gd32f30x_it.c GPIO_Init.c Hardware.c NVIC.c WDog.c
  group GD32F30x_standard_peripheral
    ../GD32F30x_Firmware_Library_V2.1.5/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Include
    Inc/: Clocks.h gd32f30x_libopt.h GPIO_Init.h Hardware.h ICF_Symbols.h NVIC.h Pin_Defs.h WDog.h
  group start-up
    ../GD32F30x_Firmware_Library_V2.1.5/Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
    ../GD32F30x_Firmware_Library_V2.1.5/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
